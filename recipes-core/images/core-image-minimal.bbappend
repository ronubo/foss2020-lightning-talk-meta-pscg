# Remember our blablabla recipe? Good. Why pollute $TOPDIR/conf/local.conf where you can elegantly customize your layer with a bbappend?
# That's (one of) the right way(s) to do so:
IMAGE_INSTALL += " corona-opinions"
